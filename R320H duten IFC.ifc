Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: f439e272-ac5b-4be2-a38f-2b32bbe4a1e7, NumberOfSaves: 7], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: R320H_ProductSummary.ifc
Time: 2026-02-03T15:49:12
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcDistributionPort (24)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_317793_1
Port_317793_2
Port_317809_1
Port_317809_2
Port_317829_1
Port_317829_2
Port_317841_1
Port_317841_2
Port_317859_1
Port_317859_2
Port_317874_1
Port_317874_2
Port_318893_1
Port_318893_2
Port_318895_1
Port_318895_2
Port_318896_1
Port_318896_2
Port_318897_1
Port_318897_2
Port_318898_1
Port_318898_2
Port_318899_1
Port_318899_2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Brushed Brass, DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Brushed Brass:317793
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_BrushedBrass, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Brushed Brass; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Brushed Copper, DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Brushed Copper:317809
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_BrushedCopper, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Brushed Copper; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Brushed Stainless Steel, DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Brushed Stainless Steel:317829
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_BrushedStainlessSteel, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Brushed Stainless Steel; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Gunmetal, DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Gunmetal:317841
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_Gunmetal, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Gunmetal; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Matte Black, DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Matte Black:317874
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_MatteBlack, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Matte Black; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Polished Stainless Steel, DBLTD_Duten_WashbasinTaps_R320H:Battery Operated Polished Stainless Steel:317859
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_Chrome, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Polished Stainless Steel; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Brushed Brass, DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Brushed Brass:318893
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_BrushedBrass, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Brushed Brass; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Brushed Copper, DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Brushed Copper:318895
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_BrushedCopper, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Brushed Copper; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Brushed Stainless Steel, DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Brushed Stainless Steel:318896
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_BrushedStainlessSteel, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Brushed Stainless Steel; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Gunmetal, DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Gunmetal:318897
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_Gunmetal, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Gunmetal; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Matte Black, DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Matte Black:318899
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_MatteBlack, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Matte Black; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2

# IfcFlowController: DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Polished Stainless Steel, DBLTD_Duten_WashbasinTaps_R320H:Mains Operated Polished Stainless Steel:318898
In: Level 0
Type - PredefinedType: FAUCET; Classification: C1030210 Uniformat (Uniformat); Material: DBLTD_Duten_Plastic_Black, DBLTD_Duten_Metal_Chrome, <Unnamed>
Type - Pset_DistributionFlowElementCommon - Reference: n/a
Type - Pset_ElementShading - Color: Defined by Finish
Type - Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Polished Stainless Steel; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Electronic tap
Type - Pset_QuantityTakeOff - Reference: n/a
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed Stainless Steel | Polished Stainless Steel | Matte Black | Brushed Brass | Brushed Coper | Gunmetal
Pset_DistributionFlowElementCommon - sets with these values: 2
